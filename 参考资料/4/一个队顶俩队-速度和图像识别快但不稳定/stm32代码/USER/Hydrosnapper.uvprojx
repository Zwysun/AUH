# Keil uVision project Hydrosnapper.uvprojx, settings and files
target Hydrosnapper (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hydrosnapper +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\BEEP;..\HARDWARE\OTIMER;..\HARDWARE\JY901;..\HARDWARE\MOTOR;..\CONTROL;..\HARDWARE\HP206C;..\HARDWARE\LED
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c battery_lock.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group HARDWARE
    ../HARDWARE/OTIMER/: otimer.c
    ../HARDWARE/JY901/: JY901.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/HP206C/: HP206C.c
    ../HARDWARE/LED/: led.c
  group CONTROL
    ../CONTROL/: linefollow.c command_from_pi.c pid_pos.c
